SRCREV = "6c67c7759e1584e1b8119d6b26737aabbfdd2ac9"

include flecs.inc

SRC_URI:append = "\
    file://flunder-lib-install-location.patch \
"
