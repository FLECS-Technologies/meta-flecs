SRCREV = "a2114ab12ed431c87c65a43e19fbd8d229e4c4b2"

include flecs.inc

SRC_URI:append = "\
    file://flunder-lib-install-location.patch \
"
